$ Spice netlist generated by v2lvs
$ v2016.4_38.25    Tue Jan 3 14:53:59 PST 2017
.INCLUDE "/home/ff/eecs251b/sky130/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice"
*.BUSDELIMITER [

.SUBCKT CLKGATE_RC_CG_MOD enable ck_in ck_out test VDD VSS
XRC_CGIC_INST ck_in enable test VSS VSS VDD VDD ck_out
+ sky130_fd_sc_hd__sdlclkp_1
.ENDS

.SUBCKT coarse_sr_PASS_NUM16 clk rst up coarse_en carry_in_incr carry_in_decr
+ coarse_out[15] coarse_out[14] coarse_out[13] coarse_out[12] coarse_out[11]
+ coarse_out[10] coarse_out[9] coarse_out[8] coarse_out[7] coarse_out[6]
+ coarse_out[5] coarse_out[4] coarse_out[3] coarse_out[2] coarse_out[1]
+ coarse_out[0] VDD VSS
*.CONNECT coarse_out_next[15] VSS
*.CONNECT coarse_out_next[14] VSS
*.CONNECT coarse_out_next[5] VSS
*.CONNECT coarse_out_next[11] VSS
*.CONNECT coarse_out_next[6] VSS
*.CONNECT coarse_out_next[3] VSS
*.CONNECT coarse_out_next[12] VSS
*.CONNECT coarse_out_next[8] VSS
*.CONNECT coarse_out_next[2] VSS
*.CONNECT coarse_out_next[0] VSS
*.CONNECT coarse_out_next[4] VSS
*.CONNECT coarse_out_next[7] VSS
*.CONNECT coarse_out_next[10] VSS
*.CONNECT coarse_out_next[9] VSS
*.CONNECT coarse_out_next[1] VSS
*.CONNECT coarse_out_next[13] VSS
XCLKGATE_RC_CG_HIER_INST0 n_103 clk CLKGATE_rc_gclk logic_0_1_net VDD VSS
+ CLKGATE_RC_CG_MOD
Xg1080__2398 n_102 n_67 n_70 n_56 n_74 VSS VSS VDD VDD coarse_out_next[13]
+ sky130_fd_sc_hd__o221ai_1
Xg1081__5107 n_72 n_56 n_54 n_57 n_84 VSS VSS VDD VDD coarse_out_next[1]
+ sky130_fd_sc_hd__o221ai_1
Xg1082__6260 n_102 n_68 n_59 n_56 n_85 VSS VSS VDD VDD coarse_out_next[9]
+ sky130_fd_sc_hd__o221ai_1
Xg1083__4319 n_102 n_59 n_60 n_56 n_83 VSS VSS VDD VDD coarse_out_next[10]
+ sky130_fd_sc_hd__o221ai_1
Xg1084__8428 n_65 n_56 n_102 n_69 n_81 VSS VSS VDD VDD coarse_out_next[7]
+ sky130_fd_sc_hd__o221ai_1
Xg1085__5526 n_102 n_63 n_66 n_56 n_80 VSS VSS VDD VDD coarse_out_next[4]
+ sky130_fd_sc_hd__o221ai_1
Xg1086__6783 n_55 n_61 carry_in_decr n_57 n_54 VSS VSS VDD VDD
+ coarse_out_next[0] sky130_fd_sc_hd__o221ai_1
Xg1087__3680 n_71 n_56 n_54 n_61 n_75 VSS VSS VDD VDD coarse_out_next[2]
+ sky130_fd_sc_hd__o221ai_1
Xg1088__1617 n_68 n_56 n_54 n_69 n_77 VSS VSS VDD VDD coarse_out_next[8]
+ sky130_fd_sc_hd__o221ai_1
Xg1089__2802 n_67 n_56 n_54 n_60 n_76 VSS VSS VDD VDD coarse_out_next[12]
+ sky130_fd_sc_hd__o221ai_1
Xg1090__1705 n_63 n_56 n_54 n_72 n_82 VSS VSS VDD VDD coarse_out_next[3]
+ sky130_fd_sc_hd__o221ai_1
Xg1091__5122 n_69 n_56 n_54 n_66 n_79 VSS VSS VDD VDD coarse_out_next[6]
+ sky130_fd_sc_hd__o221ai_1
Xg1092__8246 n_62 n_56 n_54 n_59 n_73 VSS VSS VDD VDD coarse_out_next[11]
+ sky130_fd_sc_hd__o221ai_1
Xg1093__7098 n_64 n_56 n_54 n_63 n_78 VSS VSS VDD VDD coarse_out_next[5]
+ sky130_fd_sc_hd__o221ai_1
Xg1094__6131 n_102 n_70 n_54 n_67 n_36 VSS VSS VDD VDD coarse_out_next[14]
+ sky130_fd_sc_hd__o221ai_1
Xg1095__1881 n_58 n_54 carry_in_incr up rst VSS VSS VDD VDD n_103
+ sky130_fd_sc_hd__a221o_1
Xg1096__5115 n_54 n_70 n_35 VSS VSS VDD VDD coarse_out_next[15]
+ sky130_fd_sc_hd__o21ai_0
Xg1097__7482 n_54 n_65 VSS VSS VDD VDD n_85 sky130_fd_sc_hd__or2_2
Xg1098__4733 n_102 n_61 VSS VSS VDD VDD n_84 sky130_fd_sc_hd__or2_2
Xg1099__6161 n_54 n_68 VSS VSS VDD VDD n_83 sky130_fd_sc_hd__or2_2
Xg1100__9315 n_102 n_71 VSS VSS VDD VDD n_82 sky130_fd_sc_hd__or2_2
Xg1101__9945 n_54 n_64 VSS VSS VDD VDD n_81 sky130_fd_sc_hd__or2_2
Xg1102__2883 n_54 n_71 VSS VSS VDD VDD n_80 sky130_fd_sc_hd__or2_2
Xg1103__2346 n_102 n_64 VSS VSS VDD VDD n_79 sky130_fd_sc_hd__or2_2
Xg1104__1666 n_102 n_66 VSS VSS VDD VDD n_78 sky130_fd_sc_hd__or2_2
Xg1105__7410 n_102 n_65 VSS VSS VDD VDD n_77 sky130_fd_sc_hd__or2_2
Xg1106__6417 n_102 n_62 VSS VSS VDD VDD n_76 sky130_fd_sc_hd__or2_2
Xg1107__5477 n_102 n_72 VSS VSS VDD VDD n_75 sky130_fd_sc_hd__or2_2
Xg1108__2398 n_54 n_62 VSS VSS VDD VDD n_74 sky130_fd_sc_hd__or2_2
Xg1109__5107 n_102 n_60 VSS VSS VDD VDD n_73 sky130_fd_sc_hd__or2_2
Xg1112__6260 n_42 n_51 up VSS VSS VDD VDD n_72 sky130_fd_sc_hd__mux2i_1
Xg1113__4319 n_43 n_40 up VSS VSS VDD VDD n_71 sky130_fd_sc_hd__mux2i_1
Xg1114__8428 n_37 n_41 up VSS VSS VDD VDD n_70 sky130_fd_sc_hd__mux2i_1
Xg1115__5526 n_49 n_46 up VSS VSS VDD VDD n_69 sky130_fd_sc_hd__mux2i_1
Xg1116__6783 n_44 n_49 up VSS VSS VDD VDD n_68 sky130_fd_sc_hd__mux2i_1
Xg1117__3680 n_52 n_50 up VSS VSS VDD VDD n_67 sky130_fd_sc_hd__mux2i_1
Xg1118__1617 n_46 n_43 up VSS VSS VDD VDD n_66 sky130_fd_sc_hd__mux2i_1
Xg1119__2802 coarse_en n_53 carry_in_decr VSS VSS VDD VDD n_58
+ sky130_fd_sc_hd__mux2_2
Xg1120__1705 n_39 n_48 up VSS VSS VDD VDD n_65 sky130_fd_sc_hd__mux2i_1
Xg1121__5122 n_48 n_45 up VSS VSS VDD VDD n_64 sky130_fd_sc_hd__mux2i_1
Xg1122__8246 n_45 n_42 up VSS VSS VDD VDD n_63 sky130_fd_sc_hd__mux2i_1
Xg1123__7098 n_41 n_47 up VSS VSS VDD VDD n_62 sky130_fd_sc_hd__mux2i_1
Xg1124__6131 n_40 n_38 up VSS VSS VDD VDD n_61 sky130_fd_sc_hd__mux2i_1
Xg1125__1881 n_50 n_44 up VSS VSS VDD VDD n_60 sky130_fd_sc_hd__mux2i_1
Xg1126__5115 n_47 n_39 up VSS VSS VDD VDD n_59 sky130_fd_sc_hd__mux2i_1
Xg1127__7482 up n_51 VSS VSS VDD VDD n_57 sky130_fd_sc_hd__nor2_1
Xg1130__4733 n_54 carry_in_decr VSS VSS VDD VDD n_56 sky130_fd_sc_hd__nand2_1
Xg1131__6161 n_54 n_55 VSS VSS VDD VDD n_102 sky130_fd_sc_hd__nand2_1
Xg1132 carry_in_decr VSS VSS VDD VDD n_55 sky130_fd_sc_hd__clkinv_1
Xg1133 carry_in_incr VSS VSS VDD VDD n_54 sky130_fd_sc_hd__inv_2
Xg1134 up VSS VSS VDD VDD n_53 sky130_fd_sc_hd__inv_2
Xdrc_bufs1190 coarse_out[0] VSS VSS VDD VDD n_38 sky130_fd_sc_hd__dlygate4sd1_1
Xdrc_bufs1191 coarse_out[15] VSS VSS VDD VDD n_37
+ sky130_fd_sc_hd__dlygate4sd1_1
Xdrc_bufs1192 coarse_out[14] VSS VSS VDD VDD n_52 sky130_fd_sc_hd__buf_2
Xdrc_bufs1193 coarse_out[12] VSS VSS VDD VDD n_50 sky130_fd_sc_hd__buf_2
Xdrc_bufs1194 coarse_out[8] VSS VSS VDD VDD n_49 sky130_fd_sc_hd__buf_2
Xdrc_bufs1195 coarse_out[7] VSS VSS VDD VDD n_48 sky130_fd_sc_hd__buf_2
Xdrc_bufs1196 coarse_out[11] VSS VSS VDD VDD n_47 sky130_fd_sc_hd__buf_2
Xdrc_bufs1197 coarse_out[6] VSS VSS VDD VDD n_46 sky130_fd_sc_hd__buf_2
Xdrc_bufs1198 coarse_out[5] VSS VSS VDD VDD n_45 sky130_fd_sc_hd__buf_2
Xdrc_bufs1199 coarse_out[13] VSS VSS VDD VDD n_41 sky130_fd_sc_hd__buf_2
Xdrc_bufs1200 coarse_out[10] VSS VSS VDD VDD n_44 sky130_fd_sc_hd__buf_2
Xdrc_bufs1201 coarse_out[4] VSS VSS VDD VDD n_43 sky130_fd_sc_hd__buf_2
Xdrc_bufs1202 coarse_out[3] VSS VSS VDD VDD n_42 sky130_fd_sc_hd__buf_2
Xdrc_bufs1203 coarse_out[9] VSS VSS VDD VDD n_39 sky130_fd_sc_hd__buf_2
Xdrc_bufs1204 coarse_out[2] VSS VSS VDD VDD n_40 sky130_fd_sc_hd__buf_2
Xdrc_bufs1205 coarse_out[1] VSS VSS VDD VDD n_51 sky130_fd_sc_hd__buf_2
Xg2__9315 n_56 n_52 up VSS VSS VDD VDD n_36 sky130_fd_sc_hd__nand3b_1
Xg1240__9945 n_102 n_52 up VSS VSS VDD VDD n_35 sky130_fd_sc_hd__nand3b_1
Xcoarse_out_reg[0] clk n_18 VSS VSS VDD VDD n_19 sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[15] clk n_17 VSS VSS VDD VDD n_34 sky130_fd_sc_hd__dfxtp_1
Xg688__2883 rst n_15 VSS VSS VDD VDD n_18 sky130_fd_sc_hd__nor2_1
Xg689__2346 rst n_16 VSS VSS VDD VDD n_17 sky130_fd_sc_hd__nor2_1
Xg690__1666 logic_0_2_net n_34 n_14 VSS VSS VDD VDD n_16
+ sky130_fd_sc_hd__mux2i_1
Xg691__7410 logic_0_3_net n_19 n_14 VSS VSS VDD VDD n_15
+ sky130_fd_sc_hd__mux2i_1
Xcoarse_out_reg[2] CLKGATE_rc_gclk n_13 VSS VSS VDD VDD n_21
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[12] CLKGATE_rc_gclk n_12 VSS VSS VDD VDD n_31
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[13] CLKGATE_rc_gclk n_11 VSS VSS VDD VDD n_32
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[10] CLKGATE_rc_gclk n_7 VSS VSS VDD VDD n_29
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[14] CLKGATE_rc_gclk n_10 VSS VSS VDD VDD n_33
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[1] CLKGATE_rc_gclk n_8 VSS VSS VDD VDD n_20
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[11] CLKGATE_rc_gclk n_9 VSS VSS VDD VDD n_30
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[9] CLKGATE_rc_gclk n_0 VSS VSS VDD VDD n_28
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[4] CLKGATE_rc_gclk n_6 VSS VSS VDD VDD n_23
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[5] CLKGATE_rc_gclk n_5 VSS VSS VDD VDD n_24
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[6] CLKGATE_rc_gclk n_4 VSS VSS VDD VDD n_25
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[7] CLKGATE_rc_gclk n_2 VSS VSS VDD VDD n_26
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[8] CLKGATE_rc_gclk n_1 VSS VSS VDD VDD n_27
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[3] CLKGATE_rc_gclk n_3 VSS VSS VDD VDD n_22
+ sky130_fd_sc_hd__dfxtp_1
Xg706__6417 rst logic_0_4_net VSS VSS VDD VDD n_13 sky130_fd_sc_hd__nor2b_1
Xg707__5477 rst logic_0_5_net VSS VSS VDD VDD n_12 sky130_fd_sc_hd__nor2b_1
Xg708__2398 rst logic_0_6_net VSS VSS VDD VDD n_11 sky130_fd_sc_hd__nor2b_1
Xg709__5107 rst logic_0_7_net VSS VSS VDD VDD n_10 sky130_fd_sc_hd__nor2b_1
Xg710__6260 rst logic_0_8_net VSS VSS VDD VDD n_9 sky130_fd_sc_hd__nor2b_1
Xg711__4319 rst logic_0_9_net VSS VSS VDD VDD n_8 sky130_fd_sc_hd__nor2b_1
Xg712__8428 coarse_en n_102 VSS VSS VDD VDD n_14 sky130_fd_sc_hd__nor2_1
Xg713__5526 rst logic_0_10_net VSS VSS VDD VDD n_7 sky130_fd_sc_hd__nor2b_1
Xg714__6783 rst logic_0_11_net VSS VSS VDD VDD n_6 sky130_fd_sc_hd__nor2b_1
Xg715__3680 rst logic_0_12_net VSS VSS VDD VDD n_5 sky130_fd_sc_hd__nor2b_1
Xg716__1617 rst logic_0_13_net VSS VSS VDD VDD n_4 sky130_fd_sc_hd__nor2b_1
Xg717__2802 rst logic_0_14_net VSS VSS VDD VDD n_3 sky130_fd_sc_hd__nor2b_1
Xg718__1705 rst logic_0_15_net VSS VSS VDD VDD n_2 sky130_fd_sc_hd__nor2b_1
Xg719__5122 rst logic_0_16_net VSS VSS VDD VDD n_1 sky130_fd_sc_hd__nor2b_1
Xg720__8246 rst logic_0_17_net VSS VSS VDD VDD n_0 sky130_fd_sc_hd__nor2b_1
Xg721 n_19 VSS VSS VDD VDD coarse_out[0] sky130_fd_sc_hd__buf_8
Xg722 n_34 VSS VSS VDD VDD coarse_out[15] sky130_fd_sc_hd__buf_8
Xdrc_bufs n_33 VSS VSS VDD VDD coarse_out[14] sky130_fd_sc_hd__buf_8
Xdrc_bufs723 n_20 VSS VSS VDD VDD coarse_out[1] sky130_fd_sc_hd__buf_8
Xdrc_bufs724 n_21 VSS VSS VDD VDD coarse_out[2] sky130_fd_sc_hd__buf_8
Xdrc_bufs725 n_22 VSS VSS VDD VDD coarse_out[3] sky130_fd_sc_hd__buf_8
Xdrc_bufs726 n_23 VSS VSS VDD VDD coarse_out[4] sky130_fd_sc_hd__buf_8
Xdrc_bufs727 n_24 VSS VSS VDD VDD coarse_out[5] sky130_fd_sc_hd__buf_8
Xdrc_bufs728 n_25 VSS VSS VDD VDD coarse_out[6] sky130_fd_sc_hd__buf_8
Xdrc_bufs729 n_26 VSS VSS VDD VDD coarse_out[7] sky130_fd_sc_hd__buf_8
Xdrc_bufs730 n_31 VSS VSS VDD VDD coarse_out[12] sky130_fd_sc_hd__buf_8
Xdrc_bufs731 n_28 VSS VSS VDD VDD coarse_out[9] sky130_fd_sc_hd__buf_8
Xdrc_bufs732 n_29 VSS VSS VDD VDD coarse_out[10] sky130_fd_sc_hd__buf_8
Xdrc_bufs733 n_30 VSS VSS VDD VDD coarse_out[11] sky130_fd_sc_hd__buf_8
Xdrc_bufs734 n_27 VSS VSS VDD VDD coarse_out[8] sky130_fd_sc_hd__buf_8
Xdrc_bufs735 n_32 VSS VSS VDD VDD coarse_out[13] sky130_fd_sc_hd__buf_8
Xtie_0_cell VSS VSS VDD VDD UNCONNECTED logic_0_1_net sky130_fd_sc_hd__conb_1
Xtie_0_cell1 VSS VSS VDD VDD UNCONNECTED0 logic_0_2_net sky130_fd_sc_hd__conb_1
Xtie_0_cell2 VSS VSS VDD VDD UNCONNECTED1 logic_0_3_net sky130_fd_sc_hd__conb_1
Xtie_0_cell3 VSS VSS VDD VDD UNCONNECTED2 logic_0_4_net sky130_fd_sc_hd__conb_1
Xtie_0_cell4 VSS VSS VDD VDD UNCONNECTED3 logic_0_5_net sky130_fd_sc_hd__conb_1
Xtie_0_cell5 VSS VSS VDD VDD UNCONNECTED4 logic_0_6_net sky130_fd_sc_hd__conb_1
Xtie_0_cell6 VSS VSS VDD VDD UNCONNECTED5 logic_0_7_net sky130_fd_sc_hd__conb_1
Xtie_0_cell7 VSS VSS VDD VDD UNCONNECTED6 logic_0_8_net sky130_fd_sc_hd__conb_1
Xtie_0_cell8 VSS VSS VDD VDD UNCONNECTED7 logic_0_9_net sky130_fd_sc_hd__conb_1
Xtie_0_cell9 VSS VSS VDD VDD UNCONNECTED8 logic_0_10_net
+ sky130_fd_sc_hd__conb_1
Xtie_0_cell10 VSS VSS VDD VDD UNCONNECTED9 logic_0_11_net
+ sky130_fd_sc_hd__conb_1
Xtie_0_cell11 VSS VSS VDD VDD UNCONNECTED10 logic_0_12_net
+ sky130_fd_sc_hd__conb_1
Xtie_0_cell12 VSS VSS VDD VDD UNCONNECTED11 logic_0_13_net
+ sky130_fd_sc_hd__conb_1
Xtie_0_cell13 VSS VSS VDD VDD UNCONNECTED12 logic_0_14_net
+ sky130_fd_sc_hd__conb_1
Xtie_0_cell14 VSS VSS VDD VDD UNCONNECTED13 logic_0_15_net
+ sky130_fd_sc_hd__conb_1
Xtie_0_cell15 VSS VSS VDD VDD UNCONNECTED14 logic_0_16_net
+ sky130_fd_sc_hd__conb_1
Xtie_0_cell16 VSS VSS VDD VDD UNCONNECTED15 logic_0_17_net
+ sky130_fd_sc_hd__conb_1
.ENDS

.SUBCKT CLKGATE_RC_CG_MOD_1 enable ck_in ck_out test VDD VSS
XRC_CGIC_INST ck_in enable test VSS VSS VDD VDD ck_out
+ sky130_fd_sc_hd__sdlclkp_1
.ENDS

.SUBCKT fine_sr_PASS_NUM16 clk rst comp_in fine_en fine_out[15] fine_out[14]
+ fine_out[13] fine_out[12] fine_out[11] fine_out[10] fine_out[9] fine_out[8]
+ fine_out[7] fine_out[6] fine_out[5] fine_out[4] fine_out[3] fine_out[2]
+ fine_out[1] fine_out[0] carry_out_incr carry_out_decr VDD VSS
XCLKGATE_RC_CG_HIER_INST1 n_63 clk CLKGATE_rc_gclk logic_0_1_net VDD VSS
+ CLKGATE_RC_CG_MOD_1
Xg629 n_64 VSS VSS VDD VDD n_62 sky130_fd_sc_hd__inv_1
Xg642 fine_out[12]_202 VSS VSS VDD VDD fine_out[12] sky130_fd_sc_hd__buf_8
Xg644 fine_out[7]_197 VSS VSS VDD VDD fine_out[7] sky130_fd_sc_hd__buf_8
Xg632 fine_out[11]_201 VSS VSS VDD VDD fine_out[11] sky130_fd_sc_hd__buf_8
Xg634 fine_out[4]_194 VSS VSS VDD VDD fine_out[4] sky130_fd_sc_hd__buf_8
Xg635 fine_out[13]_203 VSS VSS VDD VDD fine_out[13] sky130_fd_sc_hd__buf_8
Xg645 fine_out[1]_191 VSS VSS VDD VDD fine_out[1] sky130_fd_sc_hd__buf_8
Xg638 fine_out[2]_192 VSS VSS VDD VDD fine_out[2] sky130_fd_sc_hd__buf_8
Xg630 fine_out[10]_200 VSS VSS VDD VDD fine_out[10] sky130_fd_sc_hd__buf_8
Xg643 fine_out[9]_199 VSS VSS VDD VDD fine_out[9] sky130_fd_sc_hd__buf_8
Xg633 fine_out[6]_196 VSS VSS VDD VDD fine_out[6] sky130_fd_sc_hd__buf_8
Xg631 fine_out[8]_198 VSS VSS VDD VDD fine_out[8] sky130_fd_sc_hd__buf_8
Xg636 fine_out[0]_190 VSS VSS VDD VDD fine_out[0] sky130_fd_sc_hd__buf_8
Xg639 fine_out[15]_205 VSS VSS VDD VDD fine_out[15] sky130_fd_sc_hd__buf_8
Xg637 fine_out[5]_195 VSS VSS VDD VDD fine_out[5] sky130_fd_sc_hd__buf_8
Xg641 fine_out[3]_193 VSS VSS VDD VDD fine_out[3] sky130_fd_sc_hd__buf_8
Xg640 fine_out[14]_204 VSS VSS VDD VDD fine_out[14] sky130_fd_sc_hd__buf_8
Xcarry_out_decr_reg clk n_45 VSS VSS VDD VDD carry_out_decr
+ sky130_fd_sc_hd__dfxtp_1
Xcarry_out_incr_reg clk n_44 VSS VSS VDD VDD carry_out_incr
+ sky130_fd_sc_hd__dfxtp_1
Xg741__7098 rst n_66 fine_en VSS VSS VDD VDD n_45 sky130_fd_sc_hd__nor3b_1
Xg742__6131 rst all_ones fine_en comp_in VSS VSS VDD VDD n_44
+ sky130_fd_sc_hd__nor4bb_1
Xg743__1881 comp_in n_64 VSS VSS VDD VDD n_66 sky130_fd_sc_hd__or2_1
Xg744__5115 n_39 n_37 n_38 n_36 VSS VSS VDD VDD n_64 sky130_fd_sc_hd__nand4_1
Xg745__7482 n_41 n_42 n_40 n_43 VSS VSS VDD VDD all_ones
+ sky130_fd_sc_hd__nand4_1
Xg746__4733 fine_out[11]_201 fine_out[10]_200 fine_out[9]_199 fine_out[8]_198
+ VSS VSS VDD VDD n_43 sky130_fd_sc_hd__and4_1
Xg747__6161 fine_out[7]_197 fine_out[6]_196 fine_out[5]_195 fine_out[4]_194 VSS
+ VSS VDD VDD n_42 sky130_fd_sc_hd__and4_1
Xg748__9315 fine_out[15]_205 fine_out[14]_204 fine_out[13]_203 fine_out[12]_202
+ VSS VSS VDD VDD n_41 sky130_fd_sc_hd__and4_1
Xg749__9945 fine_out[2]_192 fine_out[1]_191 fine_out[3]_193 fine_out[0]_190 VSS
+ VSS VDD VDD n_40 sky130_fd_sc_hd__and4_1
Xg750__2883 fine_out[12]_202 fine_out[14]_204 fine_out[15]_205 fine_out[13]_203
+ VSS VSS VDD VDD n_39 sky130_fd_sc_hd__nor4_1
Xg751__2346 fine_out[0]_190 fine_out[5]_195 fine_out[6]_196 fine_out[7]_197 VSS
+ VSS VDD VDD n_38 sky130_fd_sc_hd__nor4_1
Xg752__1666 fine_out[8]_198 fine_out[10]_200 fine_out[11]_201 fine_out[9]_199
+ VSS VSS VDD VDD n_37 sky130_fd_sc_hd__nor4_1
Xg753__7410 fine_out[1]_191 fine_out[3]_193 fine_out[4]_194 fine_out[2]_192 VSS
+ VSS VDD VDD n_36 sky130_fd_sc_hd__nor4_1
Xg754__6417 fine_en rst VSS VSS VDD VDD n_63 sky130_fd_sc_hd__or2_2
Xfine_out_reg[0] CLKGATE_rc_gclk n_20 VSS VSS VDD VDD fine_out[0]_190
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[1] CLKGATE_rc_gclk n_28 VSS VSS VDD VDD fine_out[1]_191
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[6] CLKGATE_rc_gclk n_22 VSS VSS VDD VDD fine_out[6]_196
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[7] CLKGATE_rc_gclk n_31 VSS VSS VDD VDD fine_out[7]_197
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[8] CLKGATE_rc_gclk n_33 VSS VSS VDD VDD fine_out[8]_198
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[2] CLKGATE_rc_gclk n_34 VSS VSS VDD VDD fine_out[2]_192
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[9] CLKGATE_rc_gclk n_32 VSS VSS VDD VDD fine_out[9]_199
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[3] CLKGATE_rc_gclk n_35 VSS VSS VDD VDD fine_out[3]_193
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[15] CLKGATE_rc_gclk n_21 VSS VSS VDD VDD fine_out[15]_205
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[11] CLKGATE_rc_gclk n_29 VSS VSS VDD VDD fine_out[11]_201
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[4] CLKGATE_rc_gclk n_25 VSS VSS VDD VDD fine_out[4]_194
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[12] CLKGATE_rc_gclk n_23 VSS VSS VDD VDD fine_out[12]_202
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[10] CLKGATE_rc_gclk n_30 VSS VSS VDD VDD fine_out[10]_200
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[5] CLKGATE_rc_gclk n_24 VSS VSS VDD VDD fine_out[5]_195
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[14] CLKGATE_rc_gclk n_27 VSS VSS VDD VDD fine_out[14]_204
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[13] CLKGATE_rc_gclk n_26 VSS VSS VDD VDD fine_out[13]_203
+ sky130_fd_sc_hd__dfxtp_1
Xg849__5477 rst n_14 VSS VSS VDD VDD n_35 sky130_fd_sc_hd__nor2_1
Xg850__2398 rst n_17 VSS VSS VDD VDD n_34 sky130_fd_sc_hd__nor2_1
Xg851__5107 rst n_16 VSS VSS VDD VDD n_33 sky130_fd_sc_hd__nor2_1
Xg852__6260 rst n_15 VSS VSS VDD VDD n_32 sky130_fd_sc_hd__nor2_1
Xg853__4319 rst n_13 VSS VSS VDD VDD n_31 sky130_fd_sc_hd__nor2_1
Xg854__8428 rst n_19 VSS VSS VDD VDD n_30 sky130_fd_sc_hd__nor2_1
Xg855__5526 rst n_6 VSS VSS VDD VDD n_29 sky130_fd_sc_hd__nor2_1
Xg856__6783 rst n_12 VSS VSS VDD VDD n_28 sky130_fd_sc_hd__nor2_1
Xg857__3680 rst n_18 VSS VSS VDD VDD n_27 sky130_fd_sc_hd__nor2_1
Xg858__1617 rst n_9 VSS VSS VDD VDD n_26 sky130_fd_sc_hd__nor2_1
Xg859__2802 rst n_11 VSS VSS VDD VDD n_25 sky130_fd_sc_hd__nor2_1
Xg860__1705 rst n_8 VSS VSS VDD VDD n_24 sky130_fd_sc_hd__nor2_1
Xg861__5122 rst n_10 VSS VSS VDD VDD n_23 sky130_fd_sc_hd__nor2_1
Xg862__8246 rst n_7 VSS VSS VDD VDD n_22 sky130_fd_sc_hd__nor2_1
Xg863__7098 n_5 n_66 rst VSS VSS VDD VDD n_21 sky130_fd_sc_hd__a21oi_1
Xg864__6131 n_2 n_4 rst VSS VSS VDD VDD n_20 sky130_fd_sc_hd__a21oi_1
Xg865__1881 fine_out[11]_201 n_0 n_3 fine_out[9]_199 n_1 VSS VSS VDD VDD n_19
+ sky130_fd_sc_hd__a221oi_1
Xg866__5115 fine_out[15]_205 n_0 n_3 fine_out[13]_203 n_1 VSS VSS VDD VDD n_18
+ sky130_fd_sc_hd__a221oi_1
Xg867__7482 fine_out[3]_193 n_0 n_3 fine_out[1]_191 n_1 VSS VSS VDD VDD n_17
+ sky130_fd_sc_hd__a221oi_1
Xg868__4733 fine_out[9]_199 n_0 n_3 fine_out[7]_197 n_1 VSS VSS VDD VDD n_16
+ sky130_fd_sc_hd__a221oi_1
Xg869__6161 fine_out[10]_200 n_0 n_3 fine_out[8]_198 n_1 VSS VSS VDD VDD n_15
+ sky130_fd_sc_hd__a221oi_1
Xg870__9315 fine_out[4]_194 n_0 n_3 fine_out[2]_192 n_1 VSS VSS VDD VDD n_14
+ sky130_fd_sc_hd__a221oi_1
Xg871__9945 fine_out[8]_198 n_0 n_3 fine_out[6]_196 n_1 VSS VSS VDD VDD n_13
+ sky130_fd_sc_hd__a221oi_1
Xg872__2883 fine_out[2]_192 n_0 n_3 fine_out[0]_190 n_1 VSS VSS VDD VDD n_12
+ sky130_fd_sc_hd__a221oi_1
Xg873__2346 fine_out[5]_195 n_0 n_3 fine_out[3]_193 n_1 VSS VSS VDD VDD n_11
+ sky130_fd_sc_hd__a221oi_1
Xg874__1666 fine_out[13]_203 n_0 n_3 fine_out[11]_201 n_1 VSS VSS VDD VDD n_10
+ sky130_fd_sc_hd__a221oi_1
Xg875__7410 fine_out[14]_204 n_0 n_3 fine_out[12]_202 n_1 VSS VSS VDD VDD n_9
+ sky130_fd_sc_hd__a221oi_1
Xg876__6417 fine_out[6]_196 n_0 n_3 fine_out[4]_194 n_1 VSS VSS VDD VDD n_8
+ sky130_fd_sc_hd__a221oi_1
Xg877__5477 fine_out[7]_197 n_0 n_3 fine_out[5]_195 n_1 VSS VSS VDD VDD n_7
+ sky130_fd_sc_hd__a221oi_1
Xg878__2398 fine_out[12]_202 n_0 n_3 fine_out[10]_200 n_1 VSS VSS VDD VDD n_6
+ sky130_fd_sc_hd__a221oi_1
Xg879__5107 n_3 fine_out[14]_204 VSS VSS VDD VDD n_5 sky130_fd_sc_hd__nand2_1
Xg880__6260 fine_out[1]_191 n_62 n_0 VSS VSS VDD VDD n_4
+ sky130_fd_sc_hd__o21ai_1
Xg881 n_2 VSS VSS VDD VDD n_3 sky130_fd_sc_hd__inv_2
Xg882__4319 all_ones comp_in VSS VSS VDD VDD n_2 sky130_fd_sc_hd__nand2_1
Xg891 n_66 VSS VSS VDD VDD n_1 sky130_fd_sc_hd__inv_2
Xg899 comp_in VSS VSS VDD VDD n_0 sky130_fd_sc_hd__inv_2
Xtie_0_cell VSS VSS VDD VDD UNCONNECTED16 logic_0_1_net sky130_fd_sc_hd__conb_1
.ENDS

.SUBCKT top_level_sr clk rst comp_in up fine_en coarse_en fine_out[15]
+ fine_out[14] fine_out[13] fine_out[12] fine_out[11] fine_out[10] fine_out[9]
+ fine_out[8] fine_out[7] fine_out[6] fine_out[5] fine_out[4] fine_out[3]
+ fine_out[2] fine_out[1] fine_out[0] coarse_out[15] coarse_out[14]
+ coarse_out[13] coarse_out[12] coarse_out[11] coarse_out[10] coarse_out[9]
+ coarse_out[8] coarse_out[7] coarse_out[6] coarse_out[5] coarse_out[4]
+ coarse_out[3] coarse_out[2] coarse_out[1] coarse_out[0]
Xcoarse_sr clk rst up coarse_en carry_incr carry_decr coarse_out[15]
+ coarse_out[14] coarse_out[13] coarse_out[12] coarse_out[11] coarse_out[10]
+ coarse_out[9] coarse_out[8] coarse_out[7] coarse_out[6] coarse_out[5]
+ coarse_out[4] coarse_out[3] coarse_out[2] coarse_out[1] coarse_out[0] VDD VSS
+ coarse_sr_PASS_NUM16
Xfine_sr clk rst comp_in fine_en fine_out[15] fine_out[14] fine_out[13]
+ fine_out[12] fine_out[11] fine_out[10] fine_out[9] fine_out[8] fine_out[7]
+ fine_out[6] fine_out[5] fine_out[4] fine_out[3] fine_out[2] fine_out[1]
+ fine_out[0] carry_incr carry_decr VDD VSS fine_sr_PASS_NUM16
.ENDS
.GLOBAL VSS
