$ Spice netlist generated by v2lvs
$ v2016.4_38.25    Tue Jan 3 14:53:59 PST 2017
.INCLUDE "/home/aa/users/cs199-apt/Downloads/sky130_fd_sc_hd.spice"
*.BUSDELIMITER [

.SUBCKT CLKGATE_RC_CG_MOD enable ck_in ck_out test VDD VSS
XRC_CGIC_INST ck_in enable test VSS VSS VDD VDD ck_out
+ sky130_fd_sc_hd__sdlclkp_1
.ENDS

.SUBCKT coarse_sr_PASS_NUM16 clk rst up coarse_en carry_in_incr carry_in_decr
+ coarse_out[15] coarse_out[14] coarse_out[13] coarse_out[12] coarse_out[11]
+ coarse_out[10] coarse_out[9] coarse_out[8] coarse_out[7] coarse_out[6]
+ coarse_out[5] coarse_out[4] coarse_out[3] coarse_out[2] coarse_out[1]
+ coarse_out[0] VDD VSS
XCLKGATE_RC_CG_HIER_INST0 n_112 clk CLKGATE_rc_gclk logic_0_1_net VDD VSS
+ CLKGATE_RC_CG_MOD
Xg1791__2398 n_109 n_108 VSS VSS VDD VDD n_112 sky130_fd_sc_hd__nand2_1
Xg1792__5107 carry_in_decr n_106 n_107 coarse_en rst VSS VSS VDD VDD n_109
+ sky130_fd_sc_hd__a221oi_1
Xg1793__6260 n_111 carry_in_incr VSS VSS VDD VDD n_108 sky130_fd_sc_hd__xor2_1
Xg1794 n_107 VSS VSS VDD VDD n_110 sky130_fd_sc_hd__clkinv_1
Xg1795__4319 carry_in_decr carry_in_incr VSS VSS VDD VDD n_107
+ sky130_fd_sc_hd__nor2_1
Xg1796__8428 up n_106 VSS VSS VDD VDD n_111 sky130_fd_sc_hd__or2_2
Xg1797 coarse_en VSS VSS VDD VDD n_106 sky130_fd_sc_hd__inv_1
Xcoarse_out_reg[0] clk n_54 VSS VSS VDD VDD n_90 sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[1] CLKGATE_rc_gclk n_88 VSS VSS VDD VDD n_91
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[2] CLKGATE_rc_gclk n_78 VSS VSS VDD VDD n_92
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[3] CLKGATE_rc_gclk n_77 VSS VSS VDD VDD n_93
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[4] CLKGATE_rc_gclk n_84 VSS VSS VDD VDD n_94
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[5] CLKGATE_rc_gclk n_79 VSS VSS VDD VDD n_95
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[6] CLKGATE_rc_gclk n_83 VSS VSS VDD VDD n_96
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[7] CLKGATE_rc_gclk n_82 VSS VSS VDD VDD n_97
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[8] CLKGATE_rc_gclk n_85 VSS VSS VDD VDD n_98
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[9] CLKGATE_rc_gclk n_87 VSS VSS VDD VDD n_99
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[10] CLKGATE_rc_gclk n_89 VSS VSS VDD VDD n_100
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[11] CLKGATE_rc_gclk n_80 VSS VSS VDD VDD n_101
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[12] CLKGATE_rc_gclk n_76 VSS VSS VDD VDD n_102
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[13] CLKGATE_rc_gclk n_81 VSS VSS VDD VDD n_103
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[14] CLKGATE_rc_gclk n_86 VSS VSS VDD VDD n_104
+ sky130_fd_sc_hd__dfxtp_1
Xcoarse_out_reg[15] clk n_74 VSS VSS VDD VDD n_105 sky130_fd_sc_hd__dfxtp_1
Xg2381__5526 rst n_70 VSS VSS VDD VDD n_89 sky130_fd_sc_hd__nor2_1
Xg2382__6783 rst n_61 VSS VSS VDD VDD n_88 sky130_fd_sc_hd__nor2_1
Xg2383__3680 rst n_73 VSS VSS VDD VDD n_87 sky130_fd_sc_hd__nor2_1
Xg2384__1617 rst n_72 VSS VSS VDD VDD n_86 sky130_fd_sc_hd__nor2_1
Xg2385__2802 rst n_75 VSS VSS VDD VDD n_85 sky130_fd_sc_hd__nor2_1
Xg2386__1705 rst n_69 VSS VSS VDD VDD n_84 sky130_fd_sc_hd__nor2_1
Xg2388__5122 rst n_65 VSS VSS VDD VDD n_83 sky130_fd_sc_hd__nor2_1
Xg2389__8246 rst n_64 VSS VSS VDD VDD n_82 sky130_fd_sc_hd__nor2_1
Xg2390__7098 rst n_67 VSS VSS VDD VDD n_81 sky130_fd_sc_hd__nor2_1
Xg2391__6131 rst n_66 VSS VSS VDD VDD n_80 sky130_fd_sc_hd__nor2_1
Xg2392__1881 rst n_71 VSS VSS VDD VDD n_79 sky130_fd_sc_hd__nor2_1
Xg2393__5115 rst n_62 VSS VSS VDD VDD n_78 sky130_fd_sc_hd__nor2_1
Xg2394__7482 rst n_68 VSS VSS VDD VDD n_77 sky130_fd_sc_hd__nor2_1
Xg2395__4733 rst n_63 VSS VSS VDD VDD n_76 sky130_fd_sc_hd__nor2_1
Xg2396__6161 n_39 n_6 n_57 VSS VSS VDD VDD n_75 sky130_fd_sc_hd__a21oi_1
Xg2397__9315 rst n_59 VSS VSS VDD VDD n_74 sky130_fd_sc_hd__nor2b_1
Xg2398__9945 n_42 n_1 n_56 VSS VSS VDD VDD n_73 sky130_fd_sc_hd__a21oi_1
Xg2399__2883 n_44 n_6 n_48 VSS VSS VDD VDD n_72 sky130_fd_sc_hd__a21oi_1
Xg2400__2346 n_43 n_6 n_50 VSS VSS VDD VDD n_71 sky130_fd_sc_hd__a21oi_1
Xg2401__1666 n_42 n_6 n_55 VSS VSS VDD VDD n_70 sky130_fd_sc_hd__a21oi_1
Xg2402__7410 n_43 n_1 n_52 VSS VSS VDD VDD n_69 sky130_fd_sc_hd__a21oi_1
Xg2404__6417 n_32 n_1 n_60 VSS VSS VDD VDD n_68 sky130_fd_sc_hd__a21oi_1
Xg2405__5477 n_44 n_1 n_53 VSS VSS VDD VDD n_67 sky130_fd_sc_hd__a21oi_1
Xg2406__2398 n_42 n_7 n_49 VSS VSS VDD VDD n_66 sky130_fd_sc_hd__a21oi_1
Xg2407__5107 n_43 n_7 n_47 VSS VSS VDD VDD n_65 sky130_fd_sc_hd__a21oi_1
Xg2408__6260 n_39 n_1 n_58 VSS VSS VDD VDD n_64 sky130_fd_sc_hd__a21oi_1
Xg2409__4319 n_33 n_1 n_51 VSS VSS VDD VDD n_63 sky130_fd_sc_hd__a21oi_1
Xg2410__8428 n_36 n_7 n_46 VSS VSS VDD VDD n_62 sky130_fd_sc_hd__a21oi_1
Xg2411__5526 n_30 n_1 n_36 n_6 n_38 VSS VSS VDD VDD n_61
+ sky130_fd_sc_hd__a221oi_1
Xg2412__6783 n_7 n_30 coarse_en n_41 VSS VSS VDD VDD n_60
+ sky130_fd_sc_hd__o2bb2ai_1
Xg2413__3680 n_8 n_27 coarse_en n_28 n_21 VSS VSS VDD VDD n_59
+ sky130_fd_sc_hd__o221ai_1
Xg2414__1617 n_8 n_31 coarse_en n_29 VSS VSS VDD VDD n_58
+ sky130_fd_sc_hd__o22ai_1
Xg2415__2802 n_8 n_29 n_111 n_40 VSS VSS VDD VDD n_57 sky130_fd_sc_hd__o22ai_1
Xg2416__1705 n_7 n_39 coarse_en n_40 VSS VSS VDD VDD n_56
+ sky130_fd_sc_hd__o2bb2ai_1
Xg2417__5122 n_8 n_40 n_111 n_35 VSS VSS VDD VDD n_55 sky130_fd_sc_hd__o22ai_1
Xg2418__8246 rst n_45 VSS VSS VDD VDD n_54 sky130_fd_sc_hd__nor2_1
Xg2419__7098 n_6 n_33 n_8 n_34 VSS VSS VDD VDD n_53 sky130_fd_sc_hd__o2bb2ai_1
Xg2420__6131 n_6 n_32 n_8 n_41 VSS VSS VDD VDD n_52 sky130_fd_sc_hd__o2bb2ai_1
Xg2421__1881 n_8 n_35 coarse_en n_34 VSS VSS VDD VDD n_51
+ sky130_fd_sc_hd__o22ai_1
Xg2422__5115 n_7 n_32 n_111 n_31 VSS VSS VDD VDD n_50
+ sky130_fd_sc_hd__o2bb2ai_1
Xg2423__7482 n_111 n_34 coarse_en n_35 VSS VSS VDD VDD n_49
+ sky130_fd_sc_hd__o22ai_1
Xg2424__4733 n_7 n_33 n_111 n_28 VSS VSS VDD VDD n_48
+ sky130_fd_sc_hd__o2bb2ai_1
Xg2425__6161 n_111 n_29 coarse_en n_31 VSS VSS VDD VDD n_47
+ sky130_fd_sc_hd__o22ai_1
Xg2426__9315 n_6 n_30 n_111 n_41 VSS VSS VDD VDD n_46
+ sky130_fd_sc_hd__o2bb2ai_1
Xg2427__9945 n_17 n_1 n_37 VSS VSS VDD VDD n_45 sky130_fd_sc_hd__a21oi_1
Xg2428__2883 n_23 n_4 n_8 VSS VSS VDD VDD n_38 sky130_fd_sc_hd__a21oi_1
Xg2429__2346 coarse_en n_23 n_8 n_10 n_4 VSS VSS VDD VDD n_37
+ sky130_fd_sc_hd__o221ai_1
Xg2430__1666 n_27 n_22 VSS VSS VDD VDD n_44 sky130_fd_sc_hd__nand2_1
Xg2431__7410 n_3 n_110 n_24 VSS VSS VDD VDD n_43 sky130_fd_sc_hd__o21ai_1
Xg2432__6417 n_2 n_110 n_25 VSS VSS VDD VDD n_42 sky130_fd_sc_hd__o21ai_1
Xg2433__5477 n_19 n_92 carry_in_incr VSS VSS VDD VDD n_41
+ sky130_fd_sc_hd__mux2i_1
Xg2434__2398 n_18 n_98 carry_in_incr VSS VSS VDD VDD n_40
+ sky130_fd_sc_hd__mux2i_1
Xg2435__5107 n_0 n_110 n_26 VSS VSS VDD VDD n_39 sky130_fd_sc_hd__o21ai_1
Xg2436__6260 n_17 n_4 carry_in_incr n_90 VSS VSS VDD VDD n_36
+ sky130_fd_sc_hd__a22o_1
Xg2437__4319 n_11 n_100 carry_in_incr VSS VSS VDD VDD n_35
+ sky130_fd_sc_hd__mux2i_1
Xg2438__8428 n_13 n_101 carry_in_incr VSS VSS VDD VDD n_34
+ sky130_fd_sc_hd__mux2i_1
Xg2439__5526 n_102 carry_in_incr carry_in_incr n_12 VSS VSS VDD VDD n_33
+ sky130_fd_sc_hd__o2bb2ai_1
Xg2440__6783 n_93 carry_in_incr carry_in_incr n_14 VSS VSS VDD VDD n_32
+ sky130_fd_sc_hd__o2bb2ai_1
Xg2441__3680 n_20 n_95 carry_in_incr VSS VSS VDD VDD n_31
+ sky130_fd_sc_hd__mux2i_1
Xg2442__1617 n_91 carry_in_incr carry_in_incr n_15 VSS VSS VDD VDD n_30
+ sky130_fd_sc_hd__o2bb2ai_1
Xg2443__2802 n_16 n_96 carry_in_incr VSS VSS VDD VDD n_29
+ sky130_fd_sc_hd__mux2i_1
Xg2444__1705 n_5 n_4 n_105 carry_in_incr n_104 VSS VSS VDD VDD n_28
+ sky130_fd_sc_hd__a32oi_1
Xg2445__5122 n_5 n_4 n_104 carry_in_incr n_103 VSS VSS VDD VDD n_27
+ sky130_fd_sc_hd__a32oi_1
Xg2446__8246 n_9 n_99 carry_in_incr n_97 VSS VSS VDD VDD n_26
+ sky130_fd_sc_hd__a22oi_1
Xg2447__7098 n_9 n_101 carry_in_incr n_99 VSS VSS VDD VDD n_25
+ sky130_fd_sc_hd__a22oi_1
Xg2448__6131 n_9 n_96 carry_in_incr n_94 VSS VSS VDD VDD n_24
+ sky130_fd_sc_hd__a22oi_1
Xg2449__1881 n_9 n_105 VSS VSS VDD VDD n_22 sky130_fd_sc_hd__nand2_1
Xg2450__5115 carry_in_incr n_105 n_1 VSS VSS VDD VDD n_21
+ sky130_fd_sc_hd__nand3_1
Xg2451__7482 n_5 n_96 carry_in_decr n_97 VSS VSS VDD VDD n_20
+ sky130_fd_sc_hd__a22o_1
Xg2452__4733 n_5 n_93 carry_in_decr n_94 VSS VSS VDD VDD n_19
+ sky130_fd_sc_hd__a22o_1
Xg2453__6161 n_99 n_5 n_2 n_5 VSS VSS VDD VDD n_18 sky130_fd_sc_hd__o2bb2ai_1
Xg2454__9315 n_91 n_90 n_5 VSS VSS VDD VDD n_23 sky130_fd_sc_hd__mux2i_1
Xg2455__9945 n_97 n_5 n_0 n_5 VSS VSS VDD VDD n_16 sky130_fd_sc_hd__o2bb2ai_1
Xg2456__2883 n_93 n_92 n_5 VSS VSS VDD VDD n_15 sky130_fd_sc_hd__mux2i_1
Xg2457__2346 n_95 n_94 n_5 VSS VSS VDD VDD n_14 sky130_fd_sc_hd__mux2i_1
Xg2458__1666 n_5 n_102 carry_in_decr n_103 VSS VSS VDD VDD n_13
+ sky130_fd_sc_hd__a22o_1
Xg2459__7410 n_104 n_103 n_5 VSS VSS VDD VDD n_12 sky130_fd_sc_hd__mux2i_1
Xg2460__6417 n_5 n_101 carry_in_decr n_102 VSS VSS VDD VDD n_11
+ sky130_fd_sc_hd__a22o_1
Xg2461__5477 n_5 n_91 carry_in_decr n_92 VSS VSS VDD VDD n_17
+ sky130_fd_sc_hd__a22o_1
Xg2462__2398 n_90 n_5 VSS VSS VDD VDD n_10 sky130_fd_sc_hd__nor2_1
Xg2463 n_8 VSS VSS VDD VDD n_7 sky130_fd_sc_hd__inv_2
Xg2464__5107 carry_in_incr n_5 VSS VSS VDD VDD n_9 sky130_fd_sc_hd__nor2_1
Xg2465__6260 up coarse_en VSS VSS VDD VDD n_8 sky130_fd_sc_hd__nand2_1
Xg2466 n_93 VSS VSS VDD VDD coarse_out[3] sky130_fd_sc_hd__buf_8
Xg2468 n_99 VSS VSS VDD VDD coarse_out[9] sky130_fd_sc_hd__buf_8
Xg2470 n_92 VSS VSS VDD VDD coarse_out[2] sky130_fd_sc_hd__buf_8
Xg2472 n_96 VSS VSS VDD VDD coarse_out[6] sky130_fd_sc_hd__buf_8
Xg2474 n_104 VSS VSS VDD VDD coarse_out[14] sky130_fd_sc_hd__buf_8
Xg2475 coarse_en VSS VSS VDD VDD n_6 sky130_fd_sc_hd__inv_2
Xg2476 carry_in_decr VSS VSS VDD VDD n_5 sky130_fd_sc_hd__inv_2
Xg2477 carry_in_incr VSS VSS VDD VDD n_4 sky130_fd_sc_hd__inv_2
Xg2478 n_101 VSS VSS VDD VDD coarse_out[11] sky130_fd_sc_hd__buf_8
Xg2480 n_98 VSS VSS VDD VDD coarse_out[8] sky130_fd_sc_hd__buf_8
Xg2483 n_98 VSS VSS VDD VDD n_0 sky130_fd_sc_hd__inv_1
Xg2484 n_103 VSS VSS VDD VDD coarse_out[13] sky130_fd_sc_hd__buf_8
Xg2486 n_97 VSS VSS VDD VDD coarse_out[7] sky130_fd_sc_hd__buf_8
Xg2487 n_94 VSS VSS VDD VDD coarse_out[4] sky130_fd_sc_hd__buf_8
Xg2489 n_105 VSS VSS VDD VDD coarse_out[15] sky130_fd_sc_hd__buf_8
Xg2491 n_91 VSS VSS VDD VDD coarse_out[1] sky130_fd_sc_hd__buf_8
Xg2493 n_95 VSS VSS VDD VDD coarse_out[5] sky130_fd_sc_hd__buf_8
Xg2494 n_95 VSS VSS VDD VDD n_3 sky130_fd_sc_hd__inv_1
Xg2496 n_102 VSS VSS VDD VDD coarse_out[12] sky130_fd_sc_hd__buf_8
Xg2498 n_100 VSS VSS VDD VDD n_2 sky130_fd_sc_hd__inv_2
Xg2499 n_100 VSS VSS VDD VDD coarse_out[10] sky130_fd_sc_hd__buf_8
Xg2502 n_90 VSS VSS VDD VDD coarse_out[0] sky130_fd_sc_hd__buf_8
Xg2504 n_111 VSS VSS VDD VDD n_1 sky130_fd_sc_hd__inv_2
Xtie_0_cell VSS VSS VDD VDD UNCONNECTED logic_0_1_net sky130_fd_sc_hd__conb_1
.ENDS

.SUBCKT CLKGATE_RC_CG_MOD_1 enable ck_in ck_out test VDD VSS
XRC_CGIC_INST ck_in enable test VSS VSS VDD VDD ck_out
+ sky130_fd_sc_hd__sdlclkp_1
.ENDS

.SUBCKT fine_sr_PASS_NUM16 clk rst comp_in fine_en fine_out[15] fine_out[14]
+ fine_out[13] fine_out[12] fine_out[11] fine_out[10] fine_out[9] fine_out[8]
+ fine_out[7] fine_out[6] fine_out[5] fine_out[4] fine_out[3] fine_out[2]
+ fine_out[1] fine_out[0] carry_out_incr carry_out_decr VDD VSS
XCLKGATE_RC_CG_HIER_INST1 n_70 clk CLKGATE_rc_gclk logic_0_1_net VDD VSS
+ CLKGATE_RC_CG_MOD_1
Xg627 fine_out[7]_186 VSS VSS VDD VDD fine_out[7] sky130_fd_sc_hd__buf_8
Xg633 fine_out[8]_187 VSS VSS VDD VDD fine_out[8] sky130_fd_sc_hd__buf_8
Xg632 fine_out[15]_194 VSS VSS VDD VDD fine_out[15] sky130_fd_sc_hd__buf_8
Xg634 fine_out[14]_193 VSS VSS VDD VDD fine_out[14] sky130_fd_sc_hd__buf_8
Xg636 fine_out[13]_192 VSS VSS VDD VDD fine_out[13] sky130_fd_sc_hd__buf_8
Xg626 fine_out[12]_191 VSS VSS VDD VDD fine_out[12] sky130_fd_sc_hd__buf_8
Xg624 fine_out[11]_190 VSS VSS VDD VDD fine_out[11] sky130_fd_sc_hd__buf_8
Xg623 fine_out[10]_189 VSS VSS VDD VDD fine_out[10] sky130_fd_sc_hd__buf_8
Xg630 fine_out[9]_188 VSS VSS VDD VDD fine_out[9] sky130_fd_sc_hd__buf_8
Xg628 fine_out[6]_185 VSS VSS VDD VDD fine_out[6] sky130_fd_sc_hd__buf_8
Xg638 fine_out[5]_184 VSS VSS VDD VDD fine_out[5] sky130_fd_sc_hd__buf_8
Xg629 fine_out[4]_183 VSS VSS VDD VDD fine_out[4] sky130_fd_sc_hd__buf_8
Xg635 fine_out[3]_182 VSS VSS VDD VDD fine_out[3] sky130_fd_sc_hd__buf_8
Xg637 fine_out[2]_181 VSS VSS VDD VDD fine_out[2] sky130_fd_sc_hd__buf_8
Xg631 fine_out[1]_180 VSS VSS VDD VDD fine_out[1] sky130_fd_sc_hd__buf_8
Xg625 fine_out[0]_179 VSS VSS VDD VDD fine_out[0] sky130_fd_sc_hd__buf_8
Xg737__4319 n_74 fine_en VSS VSS VDD VDD carry_out_decr
+ sky130_fd_sc_hd__and2b_2
Xg738__8428 n_44 all_ones VSS VSS VDD VDD carry_out_incr
+ sky130_fd_sc_hd__nor2_4
Xg739__5526 n_53 n_48 n_45 n_47 VSS VSS VDD VDD n_74 sky130_fd_sc_hd__nand4_2
Xg740__6783 n_49 n_52 n_51 n_46 VSS VSS VDD VDD all_ones
+ sky130_fd_sc_hd__nand4_1
Xg741__3680 n_36 n_50 VSS VSS VDD VDD n_53 sky130_fd_sc_hd__nor2_2
Xg742__1617 fine_out[15]_194 fine_out[14]_193 fine_out[13]_192 fine_out[12]_191
+ VSS VSS VDD VDD n_52 sky130_fd_sc_hd__and4_1
Xg743__2802 fine_out[7]_186 fine_out[6]_185 fine_out[5]_184 fine_out[4]_183 VSS
+ VSS VDD VDD n_51 sky130_fd_sc_hd__and4_1
Xg744__1705 fine_out[12]_191 n_40 VSS VSS VDD VDD n_50
+ sky130_fd_sc_hd__nand2b_1
Xg745__5122 fine_out[11]_190 fine_out[10]_189 fine_out[9]_188 fine_out[8]_187
+ VSS VSS VDD VDD n_49 sky130_fd_sc_hd__and4_1
Xg746__8246 n_38 n_41 VSS VSS VDD VDD n_48 sky130_fd_sc_hd__and2_1
Xg747__7098 n_42 n_43 VSS VSS VDD VDD n_47 sky130_fd_sc_hd__and2_1
Xg748__6131 fine_out[2]_181 fine_out[1]_180 fine_out[3]_182 fine_out[0]_179 VSS
+ VSS VDD VDD n_46 sky130_fd_sc_hd__and4_1
Xg749__1881 n_37 n_39 VSS VSS VDD VDD n_45 sky130_fd_sc_hd__and2_1
Xg750__5115 comp_in fine_en VSS VSS VDD VDD n_44 sky130_fd_sc_hd__nand2_1
Xg751__7482 fine_out[8]_187 fine_out[9]_188 VSS VSS VDD VDD n_43
+ sky130_fd_sc_hd__nor2_1
Xg752__4733 fine_out[10]_189 fine_out[11]_190 VSS VSS VDD VDD n_42
+ sky130_fd_sc_hd__nor2_1
Xg753__6161 fine_out[4]_183 fine_out[5]_184 VSS VSS VDD VDD n_41
+ sky130_fd_sc_hd__nor2_1
Xg755__9315 comp_in fine_out[0]_179 VSS VSS VDD VDD n_40
+ sky130_fd_sc_hd__nor2_1
Xg756__9945 fine_out[1]_180 fine_out[15]_194 VSS VSS VDD VDD n_39
+ sky130_fd_sc_hd__nor2_1
Xg757__2883 fine_out[6]_185 fine_out[7]_186 VSS VSS VDD VDD n_38
+ sky130_fd_sc_hd__nor2_1
Xg758__2346 fine_en rst VSS VSS VDD VDD n_70 sky130_fd_sc_hd__or2_2
Xg759__1666 fine_out[2]_181 fine_out[3]_182 VSS VSS VDD VDD n_37
+ sky130_fd_sc_hd__nor2_1
Xg2__7410 fine_out[14]_193 fine_out[13]_192 VSS VSS VDD VDD n_36
+ sky130_fd_sc_hd__or2_1
Xfine_out_reg[0] CLKGATE_rc_gclk n_20 VSS VSS VDD VDD fine_out[0]_179
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[1] CLKGATE_rc_gclk n_26 VSS VSS VDD VDD fine_out[1]_180
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[6] CLKGATE_rc_gclk n_22 VSS VSS VDD VDD fine_out[6]_185
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[7] CLKGATE_rc_gclk n_31 VSS VSS VDD VDD fine_out[7]_186
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[8] CLKGATE_rc_gclk n_33 VSS VSS VDD VDD fine_out[8]_187
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[2] CLKGATE_rc_gclk n_34 VSS VSS VDD VDD fine_out[2]_181
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[9] CLKGATE_rc_gclk n_32 VSS VSS VDD VDD fine_out[9]_188
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[3] CLKGATE_rc_gclk n_35 VSS VSS VDD VDD fine_out[3]_182
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[15] CLKGATE_rc_gclk n_21 VSS VSS VDD VDD fine_out[15]_194
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[11] CLKGATE_rc_gclk n_29 VSS VSS VDD VDD fine_out[11]_190
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[4] CLKGATE_rc_gclk n_28 VSS VSS VDD VDD fine_out[4]_183
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[12] CLKGATE_rc_gclk n_23 VSS VSS VDD VDD fine_out[12]_191
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[10] CLKGATE_rc_gclk n_30 VSS VSS VDD VDD fine_out[10]_189
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[5] CLKGATE_rc_gclk n_24 VSS VSS VDD VDD fine_out[5]_184
+ sky130_fd_sc_hd__dfxtp_2
Xfine_out_reg[14] CLKGATE_rc_gclk n_27 VSS VSS VDD VDD fine_out[14]_193
+ sky130_fd_sc_hd__dfxtp_1
Xfine_out_reg[13] CLKGATE_rc_gclk n_25 VSS VSS VDD VDD fine_out[13]_192
+ sky130_fd_sc_hd__dfxtp_2
Xg1034__6417 rst n_15 VSS VSS VDD VDD n_35 sky130_fd_sc_hd__nor2_1
Xg1035__5477 rst n_17 VSS VSS VDD VDD n_34 sky130_fd_sc_hd__nor2_1
Xg1036__2398 rst n_18 VSS VSS VDD VDD n_33 sky130_fd_sc_hd__nor2_1
Xg1037__5107 rst n_16 VSS VSS VDD VDD n_32 sky130_fd_sc_hd__nor2_1
Xg1038__6260 rst n_13 VSS VSS VDD VDD n_31 sky130_fd_sc_hd__nor2_1
Xg1039__4319 rst n_14 VSS VSS VDD VDD n_30 sky130_fd_sc_hd__nor2_1
Xg1040__8428 rst n_19 VSS VSS VDD VDD n_29 sky130_fd_sc_hd__nor2_1
Xg1041__5526 rst n_10 VSS VSS VDD VDD n_28 sky130_fd_sc_hd__nor2_1
Xg1042__6783 rst n_8 VSS VSS VDD VDD n_27 sky130_fd_sc_hd__nor2_1
Xg1043__3680 rst n_7 VSS VSS VDD VDD n_26 sky130_fd_sc_hd__nor2_1
Xg1044__1617 rst n_11 VSS VSS VDD VDD n_25 sky130_fd_sc_hd__nor2_1
Xg1045__2802 rst n_9 VSS VSS VDD VDD n_24 sky130_fd_sc_hd__nor2_1
Xg1046__1705 rst n_6 VSS VSS VDD VDD n_23 sky130_fd_sc_hd__nor2_1
Xg1047__5122 rst n_12 VSS VSS VDD VDD n_22 sky130_fd_sc_hd__nor2_1
Xg1048__8246 n_5 n_74 rst VSS VSS VDD VDD n_21 sky130_fd_sc_hd__a21oi_1
Xg1049__7098 n_2 n_74 n_4 rst VSS VSS VDD VDD n_20 sky130_fd_sc_hd__a31oi_1
Xg1050__6131 fine_out[12]_191 n_1 n_3 fine_out[10]_189 n_0 VSS VSS VDD VDD n_19
+ sky130_fd_sc_hd__a221oi_1
Xg1051__1881 fine_out[9]_188 n_1 n_3 fine_out[7]_186 n_0 VSS VSS VDD VDD n_18
+ sky130_fd_sc_hd__a221oi_1
Xg1052__5115 fine_out[3]_182 n_1 n_3 fine_out[1]_180 n_0 VSS VSS VDD VDD n_17
+ sky130_fd_sc_hd__a221oi_1
Xg1053__7482 fine_out[10]_189 n_1 n_3 fine_out[8]_187 n_0 VSS VSS VDD VDD n_16
+ sky130_fd_sc_hd__a221oi_1
Xg1054__4733 fine_out[4]_183 n_1 n_3 fine_out[2]_181 n_0 VSS VSS VDD VDD n_15
+ sky130_fd_sc_hd__a221oi_1
Xg1055__6161 fine_out[11]_190 n_1 n_3 fine_out[9]_188 n_0 VSS VSS VDD VDD n_14
+ sky130_fd_sc_hd__a221oi_1
Xg1056__9315 fine_out[8]_187 n_1 n_3 fine_out[6]_185 n_0 VSS VSS VDD VDD n_13
+ sky130_fd_sc_hd__a221oi_1
Xg1057__9945 fine_out[7]_186 n_1 n_3 fine_out[5]_184 n_0 VSS VSS VDD VDD n_12
+ sky130_fd_sc_hd__a221oi_1
Xg1058__2883 fine_out[14]_193 n_1 n_3 fine_out[12]_191 n_0 VSS VSS VDD VDD n_11
+ sky130_fd_sc_hd__a221oi_1
Xg1059__2346 fine_out[5]_184 n_1 n_3 fine_out[3]_182 n_0 VSS VSS VDD VDD n_10
+ sky130_fd_sc_hd__a221oi_1
Xg1060__1666 fine_out[6]_185 n_1 n_3 fine_out[4]_183 n_0 VSS VSS VDD VDD n_9
+ sky130_fd_sc_hd__a221oi_1
Xg1061__7410 fine_out[15]_194 n_1 n_3 fine_out[13]_192 n_0 VSS VSS VDD VDD n_8
+ sky130_fd_sc_hd__a221oi_1
Xg1062__6417 fine_out[2]_181 n_1 n_3 fine_out[0]_179 n_0 VSS VSS VDD VDD n_7
+ sky130_fd_sc_hd__a221oi_1
Xg1063__5477 fine_out[13]_192 n_1 n_3 fine_out[11]_190 n_0 VSS VSS VDD VDD n_6
+ sky130_fd_sc_hd__a221oi_1
Xg1064__2398 n_3 fine_out[14]_193 VSS VSS VDD VDD n_5 sky130_fd_sc_hd__nand2_1
Xg1065__5107 fine_out[1]_180 n_1 VSS VSS VDD VDD n_4 sky130_fd_sc_hd__nand2_1
Xg1066 n_2 VSS VSS VDD VDD n_3 sky130_fd_sc_hd__inv_2
Xg1067__6260 all_ones comp_in VSS VSS VDD VDD n_2 sky130_fd_sc_hd__nand2_1
Xg1073 comp_in VSS VSS VDD VDD n_1 sky130_fd_sc_hd__inv_2
Xg1074 n_74 VSS VSS VDD VDD n_0 sky130_fd_sc_hd__inv_2
Xtie_0_cell VSS VSS VDD VDD UNCONNECTED0 logic_0_1_net sky130_fd_sc_hd__conb_1
.ENDS

.SUBCKT top_level_sr clk rst comp_in up fine_en coarse_en fine_out[15]
+ fine_out[14] fine_out[13] fine_out[12] fine_out[11] fine_out[10] fine_out[9]
+ fine_out[8] fine_out[7] fine_out[6] fine_out[5] fine_out[4] fine_out[3]
+ fine_out[2] fine_out[1] fine_out[0] coarse_out[15] coarse_out[14]
+ coarse_out[13] coarse_out[12] coarse_out[11] coarse_out[10] coarse_out[9]
+ coarse_out[8] coarse_out[7] coarse_out[6] coarse_out[5] coarse_out[4]
+ coarse_out[3] coarse_out[2] coarse_out[1] coarse_out[0] VDD VSS
Xcoarse_sr clk rst up coarse_en carry_incr carry_decr coarse_out[15]
+ coarse_out[14] coarse_out[13] coarse_out[12] coarse_out[11] coarse_out[10]
+ coarse_out[9] coarse_out[8] coarse_out[7] coarse_out[6] coarse_out[5]
+ coarse_out[4] coarse_out[3] coarse_out[2] coarse_out[1] coarse_out[0] VDD VSS
+ coarse_sr_PASS_NUM16
Xfine_sr clk rst comp_in fine_en fine_out[15] fine_out[14] fine_out[13]
+ fine_out[12] fine_out[11] fine_out[10] fine_out[9] fine_out[8] fine_out[7]
+ fine_out[6] fine_out[5] fine_out[4] fine_out[3] fine_out[2] fine_out[1]
+ fine_out[0] carry_incr carry_decr VDD VSS fine_sr_PASS_NUM16
.ENDS
