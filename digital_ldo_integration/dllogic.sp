$ Spice netlist generated by v2lvs
$ v2016.4_38.25    Tue Jan 3 14:53:59 PST 2017
*.INCLUDE "/home/ff/eecs251b/sky130/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice"
.INCLUDE "./sky130_fd_sc_hd.spice"
*.BUSDELIMITER [

.SUBCKT DigitalLDOLogic vdd vss clk rst comp_in out[31] out[30] out[29] out[28] out[27]
+ out[26] out[25] out[24] out[23] out[22] out[21] out[20] out[19] out[18]
+ out[17] out[16] out[15] out[14] out[13] out[12] out[11] out[10] out[9] out[8]
+ out[7] out[6] out[5] out[4] out[3] out[2] out[1] out[0]
Xpass_reg[30] clk n_64 vss vss vdd vdd pass[30]  sky130_fd_sc_hd__dfxtp_1
Xg525__2398 pass[31] n_61 pass[29] comp_in rst vss vss vdd vdd n_64 sky130_fd_sc_hd__a221o_1
Xpass_reg[26] clk n_41 vss vss vdd vdd pass[26] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[4] clk n_50 vss vss vdd vdd pass[4] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[18] clk n_33 vss vss vdd vdd pass[18] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[19] clk n_55 vss vss vdd vdd pass[19] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[20] clk n_52 vss vss vdd vdd pass[20] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[7] clk n_43 vss vss vdd vdd pass[7] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[21] clk n_60 vss vss vdd vdd pass[21] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[22] clk n_39 vss vss vdd vdd pass[22] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[8] clk n_40 vss vss vdd vdd pass[8] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[29] clk n_56 vss vss vdd vdd pass[29] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[23] clk n_38 vss vss vdd vdd pass[23] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[24] clk n_37 vss vss vdd vdd pass[24] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[25] clk n_36 vss vss vdd vdd pass[25] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[1] clk n_54 vss vss vdd vdd pass[1] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[2] clk n_59 vss vss vdd vdd pass[2] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[6] clk n_35 vss vss vdd vdd pass[6] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[3] clk n_53 vss vss vdd vdd pass[3] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[5] clk n_44 vss vss vdd vdd pass[5] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[10] clk n_42 vss vss vdd vdd pass[10] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[11] clk n_57 vss vss vdd vdd pass[11] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[9] clk n_58 vss vss vdd vdd pass[9] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[27] clk n_34 vss vss vdd vdd pass[27] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[28] clk n_46 vss vss vdd vdd pass[28] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[12] clk n_47 vss vss vdd vdd pass[12] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[13] clk n_62 vss vss vdd vdd pass[13] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[14] clk n_51 vss vss vdd vdd pass[14] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[15] clk n_49 vss vss vdd vdd pass[15] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[16] clk n_48 vss vss vdd vdd pass[16] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[17] clk n_45 vss vss vdd vdd pass[17] sky130_fd_sc_hd__dfxtp_1
Xg555 pass[31] vss vss vdd vdd out[31] sky130_fd_sc_hd__buf_8
Xg578__5107 pass[14] n_61 pass[12] comp_in rst vss vss vdd vdd n_62 sky130_fd_sc_hd__a221o_1
Xg556__6260 pass[22] n_61 pass[20] comp_in rst vss vss vdd vdd n_60 sky130_fd_sc_hd__a221o_1
Xg575__4319 pass[3] n_61 pass[1] comp_in rst vss vss vdd vdd n_59 sky130_fd_sc_hd__a221o_1
Xg557__8428 pass[10] n_61 pass[8] comp_in rst vss vss vdd vdd n_58 sky130_fd_sc_hd__a221o_1
Xg576__5526 pass[12] n_61 pass[10] comp_in rst vss vss vdd vdd n_57 sky130_fd_sc_hd__a221o_1
Xg577__6783 pass[30] n_61 pass[28] comp_in rst vss vss vdd vdd n_56 sky130_fd_sc_hd__a221o_1
Xg558__3680 pass[20] n_61 pass[18] comp_in rst vss vss vdd vdd n_55 sky130_fd_sc_hd__a221o_1
Xg574__1617 pass[2] n_61 pass[0] comp_in rst vss vss vdd vdd n_54 sky130_fd_sc_hd__a221o_1
Xg579__2802 pass[4] n_61 pass[2] comp_in rst vss vss vdd vdd n_53 sky130_fd_sc_hd__a221o_1
Xg559__1705 pass[21] n_61 pass[19] comp_in rst vss vss vdd vdd n_52 sky130_fd_sc_hd__a221o_1
Xg580__5122 pass[15] n_61 pass[13] comp_in rst vss vss vdd vdd n_51 sky130_fd_sc_hd__a221o_1
Xg581__8246 pass[5] n_61 pass[3] comp_in rst vss vss vdd vdd n_50 sky130_fd_sc_hd__a221o_1
Xg582__7098 pass[16] n_61 pass[14] comp_in rst vss vss vdd vdd n_49 sky130_fd_sc_hd__a221o_1
Xg583__6131 pass[17] n_61 pass[15] comp_in rst vss vss vdd vdd n_48 sky130_fd_sc_hd__a221o_1
Xg560__1881 pass[13] n_61 pass[11] comp_in rst vss vss vdd vdd n_47 sky130_fd_sc_hd__a221o_1
Xg573__5115 pass[29] n_61 pass[27] comp_in rst vss vss vdd vdd n_46 sky130_fd_sc_hd__a221o_1
Xg584__7482 pass[18] n_61 pass[16] comp_in rst vss vss vdd vdd n_45 sky130_fd_sc_hd__a221o_1
Xg585__4733 pass[6] n_61 pass[4] comp_in rst vss vss vdd vdd n_44 sky130_fd_sc_hd__a221o_1
Xg562__6161 pass[8] n_61 pass[6] comp_in rst vss vss vdd vdd n_43 sky130_fd_sc_hd__a221o_1
Xg586__9315 pass[11] n_61 pass[9] comp_in rst vss vss vdd vdd n_42 sky130_fd_sc_hd__a221o_1
Xg563__9945 pass[27] n_61 pass[25] comp_in rst vss vss vdd vdd n_41 sky130_fd_sc_hd__a221o_1
Xg564__2883 pass[9] n_61 pass[7] comp_in rst vss vss vdd vdd n_40 sky130_fd_sc_hd__a221o_1
Xg565__2346 pass[23] n_61 pass[21] comp_in rst vss vss vdd vdd n_39 sky130_fd_sc_hd__a221o_1
Xg566__1666 pass[24] n_61 pass[22] comp_in rst vss vss vdd vdd n_38 sky130_fd_sc_hd__a221o_1
Xg567__7410 pass[25] n_61 pass[23] comp_in rst vss vss vdd vdd n_37 sky130_fd_sc_hd__a221o_1
Xg568__6417 pass[26] n_61 pass[24] comp_in rst vss vss vdd vdd n_36 sky130_fd_sc_hd__a221o_1
Xg561__5477 pass[7] n_61 pass[5] comp_in rst vss vss vdd vdd n_35 sky130_fd_sc_hd__a221o_1
Xg572__2398 pass[28] n_61 pass[26] comp_in rst vss vss vdd vdd n_34 sky130_fd_sc_hd__a221o_1
Xg571__5107 pass[19] n_61 pass[17] comp_in rst vss vss vdd vdd n_33 sky130_fd_sc_hd__a221o_1
Xpass_reg[31] clk n_32 vss vss vdd vdd pass[31] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[0] clk n_31 vss vss vdd vdd pass[0] sky130_fd_sc_hd__dfxtp_1
Xg587__6260 pass[30] comp_in rst vss vss vdd vdd n_32 sky130_fd_sc_hd__a21o_1
Xg588__4319 comp_in rst pass[1] vss vss vdd vdd n_31 sky130_fd_sc_hd__or3_1
Xg597 pass[21] vss vss vdd vdd out[21] sky130_fd_sc_hd__buf_8
Xg599 pass[24] vss vss vdd vdd out[24] sky130_fd_sc_hd__buf_8
Xg591 pass[11] vss vss vdd vdd out[11] sky130_fd_sc_hd__buf_8
Xg601 pass[7] vss vss vdd vdd out[7] sky130_fd_sc_hd__buf_8
Xg608 pass[14] vss vss vdd vdd out[14] sky130_fd_sc_hd__buf_8
Xg602 pass[12] vss vss vdd vdd out[12] sky130_fd_sc_hd__buf_8
Xg594 pass[28] vss vss vdd vdd out[28]  sky130_fd_sc_hd__buf_8
Xg619 pass[23] vss vss vdd vdd out[23] sky130_fd_sc_hd__buf_8
Xg616 pass[2] vss vss vdd vdd out[2] sky130_fd_sc_hd__buf_8
Xg609 pass[1] vss vss vdd vdd out[1] sky130_fd_sc_hd__buf_8
Xg598 pass[5] vss vss vdd vdd out[5] sky130_fd_sc_hd__buf_8
Xg612 pass[29] vss vss vdd vdd out[29] sky130_fd_sc_hd__buf_8
Xg596 pass[25] vss vss vdd vdd out[25] sky130_fd_sc_hd__buf_8
Xg610 pass[30] vss vss vdd vdd out[30] sky130_fd_sc_hd__buf_8
Xg620 pass[27] vss vss vdd vdd out[27] sky130_fd_sc_hd__buf_8
Xg604 comp_in vss vss vdd vdd n_61 sky130_fd_sc_hd__inv_2
Xg606 pass[4] vss vss vdd vdd out[4] sky130_fd_sc_hd__buf_8
Xg615 pass[9] vss vss vdd vdd out[9] sky130_fd_sc_hd__buf_8
Xg592 pass[17] vss vss vdd vdd out[17] sky130_fd_sc_hd__buf_8
Xg603 pass[10] vss vss vdd vdd out[10] sky130_fd_sc_hd__buf_8
Xg607 pass[26] vss vss vdd vdd out[26] sky130_fd_sc_hd__buf_8
Xg605 pass[15] vss vss vdd vdd out[15] sky130_fd_sc_hd__buf_8
Xg589 pass[0] vss vss vdd vdd out[0] sky130_fd_sc_hd__buf_8
Xg613 pass[8] vss vss vdd vdd out[8] sky130_fd_sc_hd__buf_8
Xg611 pass[20] vss vss vdd vdd out[20] sky130_fd_sc_hd__buf_8
Xg595 pass[13] vss vss vdd vdd out[13] sky130_fd_sc_hd__buf_8
Xg600 pass[19] vss vss vdd vdd out[19] sky130_fd_sc_hd__buf_8
Xg593 pass[18] vss vss vdd vdd out[18] sky130_fd_sc_hd__buf_8
Xg614 pass[22] vss vss vdd vdd out[22] sky130_fd_sc_hd__buf_8
Xg617 pass[16] vss vss vdd vdd out[16] sky130_fd_sc_hd__buf_8
Xg590 pass[3] vss vss vdd vdd out[3] sky130_fd_sc_hd__buf_8
Xg618 pass[6] vss vss vdd vdd out[6] sky130_fd_sc_hd__buf_8
.ENDS
