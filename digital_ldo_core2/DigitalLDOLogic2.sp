$ Spice netlist generated by v2lvs
$ v2024.3_16.10    Tue Jul 9 11:27:02 PDT 2024
.INCLUDE "/home/aa/users/cs199-apt/Downloads/sky130_fd_sc_hd.spice"
*.BUSDELIMITER [

.SUBCKT DigitalLDOLogic VDD VSS clk rst comp_in out[7] out[6] out[5] out[4] out[3]
+ out[2] out[1] out[0]
Xpass_reg[6] clk n_17 VSS VSS VDD VDD pass[6] sky130_fd_sc_hd__dfxtp_1
Xg117__2398 pass[7] n_14 pass[5] comp_in rst VSS VSS VDD VDD n_17
+ sky130_fd_sc_hd__a221o_1
Xg123 pass[7] VSS VSS VDD VDD out[7] sky130_fd_sc_hd__buf_8
Xpass_reg[4] clk n_13 VSS VSS VDD VDD pass[4] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[3] clk n_12 VSS VSS VDD VDD pass[3] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[5] clk n_15 VSS VSS VDD VDD pass[5] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[1] clk n_10 VSS VSS VDD VDD pass[1] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[2] clk n_11 VSS VSS VDD VDD pass[2] sky130_fd_sc_hd__dfxtp_1
Xpass_reg[7] clk n_9 VSS VSS VDD VDD pass[7] sky130_fd_sc_hd__dfxtp_1
Xg124__5107 pass[6] n_14 pass[4] comp_in rst VSS VSS VDD VDD n_15
+ sky130_fd_sc_hd__a221o_1
Xg130__6260 pass[5] n_14 pass[3] comp_in rst VSS VSS VDD VDD n_13
+ sky130_fd_sc_hd__a221o_1
Xg127__4319 pass[4] n_14 pass[2] comp_in rst VSS VSS VDD VDD n_12
+ sky130_fd_sc_hd__a221o_1
Xg128__8428 pass[3] n_14 pass[1] comp_in rst VSS VSS VDD VDD n_11
+ sky130_fd_sc_hd__a221o_1
Xg129__5526 pass[2] n_14 pass[0] comp_in rst VSS VSS VDD VDD n_10
+ sky130_fd_sc_hd__a221o_1
Xpass_reg[0] clk n_8 VSS VSS VDD VDD pass[0] sky130_fd_sc_hd__dfxtp_1
Xg131__6783 n_6 comp_in rst VSS VSS VDD VDD n_9 sky130_fd_sc_hd__a21o_1
Xg132__3680 comp_in rst pass[1] VSS VSS VDD VDD n_8 sky130_fd_sc_hd__or3_1
Xg138 n_6 VSS VSS VDD VDD out[6] sky130_fd_sc_hd__buf_8
Xg137 pass[0] VSS VSS VDD VDD out[0] sky130_fd_sc_hd__buf_8
Xg135 pass[4] VSS VSS VDD VDD out[4] sky130_fd_sc_hd__buf_8
Xg139 pass[6] VSS VSS VDD VDD n_6 sky130_fd_sc_hd__clkbuf_1
Xg136 comp_in VSS VSS VDD VDD n_14 sky130_fd_sc_hd__inv_1
Xg141 pass[1] VSS VSS VDD VDD out[1] sky130_fd_sc_hd__buf_8
Xg140 pass[2] VSS VSS VDD VDD out[2] sky130_fd_sc_hd__buf_8
Xg134 pass[5] VSS VSS VDD VDD out[5] sky130_fd_sc_hd__buf_8
Xg133 pass[3] VSS VSS VDD VDD out[3] sky130_fd_sc_hd__buf_8
.ENDS
